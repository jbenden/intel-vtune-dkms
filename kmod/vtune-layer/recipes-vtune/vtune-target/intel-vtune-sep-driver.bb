require intel-vtune-common.inc


SUMMARY = "Intel(R) VTune(TM) for Systems standalone sampling enabling target package"
DESCRIPTION = "Intel(R) VTune(TM) for Systems standalone sampling enabling target package"

PROVIDES += " virtual/intel-vtune-sep"

VTUNE_DRIVERS="sep"
