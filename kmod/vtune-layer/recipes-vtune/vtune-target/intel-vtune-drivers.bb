require intel-vtune-common.inc


SUMMARY = "Intel(R) VTune(TM) for Systems target package"
DESCRIPTION = "Intel(R) VTune(TM) for Systems target package"

PROVIDES += " virtual/intel-vtune-sep virtual/intel-vtune-vtss"

VTUNE_DRIVERS="all"
